options:
  parameters:
    author: Jon Kraft
    generate_options: qt_gui
    id: Pluto_pyadi_rev6_TDD
    output_language: python
    title: Pluto_pyadi_TDD
  states: {}

blocks:
- name: LOfreq
  id: variable_qtgui_range
  parameters:
    start: int(0.1e9)
    step: int(0.1e9)
    stop: int(6e9)
    value: int(2e9)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: size_fft
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '-70'
    step: '1'
    stop: '0'
    value: '-30'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    LOfreq: int(LOfreq)
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport time\nfrom gnuradio import gr\nimport adi  # import pyadi-iio library\nprint(adi.__version__)  # needs to be >=0.0.18 to have the TDD engine\nfrom scipy import signal\nfrom scipy.signal import chirp, spectrogram, hilbert\n\nclass blk(gr.sync_block):\n    def __init__(self, samp_rate=1e6, rx_gain=20, tx_gain=-30, LOfreq=2e9):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(self,\n            name='Pluto Python Control Block',   # will show up in GRC\n            in_sig=[],\n            out_sig=[np.complex64, np.complex64])\n        self.set_min_output_buffer(4096*16)\n        self.samp_rate = samp_rate\n        self.rx_gain = rx_gain\n        self.tx_gain = tx_gain\n        self.LOfreq = LOfreq\n        self.initSDR = 0               \n    def work(self, input_items, output_items):\n        if self.initSDR == 0:\n            # Setup SDR\n            sdr_ip = \"ip:192.168.2.1\"   # default Pluto IP address\n            #sdr_ip = \"ip:phaser.local:50901\"\n            self.sdr = adi.ad9361(uri=sdr_ip)\n            # Configure Rx\n            self.sdr.sample_rate = int(self.samp_rate)\n            self.samp_rate = int(self.sdr.sample_rate)\n            self.sdr.rx_lo = int(self.LOfreq)   \n            self.sdr.rx_enabled_channels = [0, 1]   # enable Rx1 (voltage0) and Rx2 (voltage1)\n            self.sdr.gain_control_mode_chan0 = 'manual'  # manual or slow_attack\n            self.sdr.gain_control_mode_chan1 = 'manual'  # manual or slow_attack\n            self.sdr.rx_hardwaregain_chan0 = int(self.rx_gain)   # must be between -3 and 70\n            self.sdr.rx_hardwaregain_chan1 = int(self.rx_gain)   # must be between -3 and 70\n            self.sdr._rxadc.set_kernel_buffers_count(1)  # Default is 4 Rx buffers are stored\n            # Configure Tx\n            self.sdr.tx_lo = int(self.LOfreq)   \n            self.sdr.tx_enabled_channels = [0, 1]\n            self.sdr.tx_hardwaregain_chan0 = int(self.tx_gain)   # must be between 0 and -88\n            self.sdr.tx_hardwaregain_chan1 = int(self.tx_gain)   # must be between 0 and -88\n            self.sdr.tx_cyclic_buffer = True\n\n            # Configure TDD properties\n            self.tddn = adi.tddn(sdr_ip) \n            self.tddn.enable              = 0     # disable TDD to change properties\n            self.tddn.sync_external       = 1     # enable sync trigger\n            self.tddn.startup_delay_ms    = 0\n            self.tddn.frame_length_ms     = 8\n            self.tddn.burst_count         = 0     # 0=repeat Tx waveform\n        \n            self.tddn.channel[0].on_ms    = 0\n            self.tddn.channel[0].off_ms   = 10\n            self.tddn.channel[0].polarity = 0\n            self.tddn.channel[0].enable   = 1\n        \n            # RX DMA SYNC\n            self.tddn.channel[1].on_ms    = 0\n            self.tddn.channel[1].off_raw  = 10\n            self.tddn.channel[1].polarity = 0\n            self.tddn.channel[1].enable   = 1\n            \n            # TX DMA SYNC\n            self.tddn.channel[2].on_ms    = 0\n            self.tddn.channel[2].off_raw  = 10\n            self.tddn.channel[2].polarity = 0\n            self.tddn.channel[2].enable   = 1\n\n            # Create 4 FMCW chirps and transmit\n            T = 32768/(4*self.samp_rate)      # total time range (sec)\n            t = np.arange(0, T, 1/self.samp_rate)\n            real_chirp = chirp(t, f0=0, f1=self.samp_rate/4, t1=T, method='linear') * (0.9 * 2**11)\n            self.iq_chirp = hilbert(real_chirp)   # convert the real chirp into a complex (I and Q) chirp\n            self.iq_chirp = np.append(self.iq_chirp, [self.iq_chirp, self.iq_chirp, self.iq_chirp])\n            self.sdr.tx([self.iq_chirp, self.iq_chirp])\n            self.tddn.enable        = 1     # enable TDD engine\n            self.tddn.sync_soft     = 1     # start synchronization\n            self.initSDR            = 1\n\n        self.sdr.rx_buffer_size = len(output_items[0])\n        self.sdr.rx_hardwaregain_chan0 = int(self.rx_gain)\n        self.sdr.rx_hardwaregain_chan1 = int(self.rx_gain)\n        self.sdr.tx_hardwaregain_chan0 = int(self.tx_gain)\n        self.sdr.tx_hardwaregain_chan1 = int(self.tx_gain)\n        self.sdr.rx_lo = int(self.LOfreq)\n        self.sdr.tx_lo = int(self.LOfreq)\n\n        self.data = self.sdr.rx()\n\n        # data and ouput buffer lengths should be equal, but just in case they are not....\n        len_data = len(self.data[0])\n        len_output = len(output_items[0])\n        output_size = min(len_data, len_output)\n        output_items[0][:output_size] = self.data[0][:output_size]\n        output_items[1][:output_size] = self.iq_chirp[:output_size] / (max(self.iq_chirp))\n        if len_output > len_data:\n            output_items[0][len_data:] = np.ones((len_output - len_data))*1j*1E-9\n        return len(output_items[0])\n\n    def stop(self):\n        self.sdr.tx_destroy_buffer()\n        self.sdr.rx_destroy_buffer()\n        self.tddn.enable = 0\n\n\n\n\n"
    comment: |-
      This python program is for 2Rx/2Tx Rev C Pluto
      Connect SMA cable from Tx to Rx
    rx_gain: int(rx_gain)
    samp_rate: int(samp_rate)
    tx_gain: int(tx_gain)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: '""'
    bw: samp_rate
    comment: |-
      set FFT size to int(size_fft)
      set update rate to int(samp_rate/(3.14*size_fft))
    fc: '0'
    fftsize: int(size_fft)
    rate: int(samp_rate/(3.14*size_fft))
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: int(size_fft)
    rate: int(samp_rate/(3.14*size_fft))
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '1', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
